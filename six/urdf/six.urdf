Commit message: Add files via upload

File: six/urdf/six.urdf (robot description, URDF)
Before this commit: robot six, 6 links, 5 joints
Joints:
- joint lidar_joint: origin xyz=0.7 0 0.01 rpy=0 0 0 -> xyz=0 0 0.19 rpy=0 0 0
